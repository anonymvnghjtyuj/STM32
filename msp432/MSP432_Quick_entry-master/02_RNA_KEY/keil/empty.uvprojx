# Keil uVision project empty.uvprojx, settings and files
target empty (ARM-ADS)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IROM(0x00000000,0x00100000) IRAM(0x20000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty
  AfterMake: fromelf --bin --output .\Build\empty.bin .\Build\empty.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;..\hardware;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group Hardware
    ../hardware/: led.c key.c
software components: CMSIS:CORE 3.40.0, Device:Startup 3.2.3
