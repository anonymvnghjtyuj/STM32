# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HandWare;.\HandWare\key;.\HandWare\delay;.\HandWare\Digital_tube;.\HandWare\led;.\HandWare\produce_wave
  group Source Group 1
    ./: main.c
  group HandWare
    ./HandWare/key/: key.c
    ./HandWare/delay/: delay.c
    ./HandWare/Digital_tube/: Digital_tube.c
    ./HandWare/produce_wave/: produce_wave.c produce_wave.h
