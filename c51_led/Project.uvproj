# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HandWare;.\HandWare\key;.\HandWare\led
  group Source Group 1
    ./: main.c
  group HandWare
    ./HandWare/: delay.c delay.h
    ./HandWare/key/: key.c key.h
    ./HandWare/led/: led.c led.h
